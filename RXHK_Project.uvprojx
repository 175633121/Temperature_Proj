# Keil uVision project RXHK_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\Compile5.06)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Rxhk_WWDG_Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\CMSIS\Core\CM3\startup\arm;.\Source\CMSIS\Core\CM3;.\Source\App;.\Source\STM32F10x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group App
    ./Source/: main.c drv_wwdg.c drv_wwdg.h
  group Lib
    ./Source/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_wwdg.c
